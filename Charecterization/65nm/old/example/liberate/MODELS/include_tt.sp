**
.LIB '/home/VLSI_ANALOG/UMC180/Designkits/Cadence_6.1/Models/Spectre/MM180_REG18_V124.lib.scs' tt
